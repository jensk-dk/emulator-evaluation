# As meta-oss-vendor-raspberrypi has it: HLS, which RDK-E's common layer leaves out.
EXTRA_OEMESON:append:tvemu = " -Dhls=enabled"
